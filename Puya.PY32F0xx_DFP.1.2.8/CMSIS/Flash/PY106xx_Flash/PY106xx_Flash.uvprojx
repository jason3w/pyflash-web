# Keil uVision project PY106xx_Flash.uvprojx, settings and files
target PY106xx_8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: PY106xx_8
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY106xx_8
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY106xx_16 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_16
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY106xx_16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY106xx_20 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_20
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY106xx_20
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY106xx_24 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_24
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY106xx_24
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY106xx_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY106xx_32
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY106xx_48 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_48
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY106xx_48
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY106xx_64 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_64
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY106xx_64
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_OB
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 wLevel=2
  c define: FLASH_OB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OTP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: PY106xx_OTP
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM FLASH_OTP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
